# Keil uVision project STM32F405RG.uvprojx, settings and files
target STM32F405RG (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F405RG +hex
  AfterMake: fromelf --bin --output ..\BIN\recflash.bin  ..\MDK-ARM\STM32F405RG\STM32F405RG.axf
  AfterMake: ..\MDK-ARM\Keil5_disp_size_bar_v0.4.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,STM32F40XX
  c misc: --no_multibyte_chars
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../components/systemview;../application;../Drivers/STM32F4xx_StdPeriph_Driver/inc;../bsp;../components/algorithm;../components/log;../components/support;../components/event_mgr;../components/easyflash/inc;../components/mbr_dev;../components/letter_shell
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c rng.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group systemviewe
    ../components/systemview/: SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group Drivers/STM32F4xx_STD_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group application
    ../application/: init.c monitor_task.c letter_shell_task.c offline_task.c app_task.c comm_task.c
  group bsp
    ../bsp/: drv_uart.c drv_led.c drv_key.c drv_motor.c drv_comm.c
  group support
    ../components/support/: fifo.c fsm.c mf_crc.c u8tool.c
    ../components/algorithm/: my_pid.c
  group log
    ../components/log/: log.c
  group event_mgr
    ../components/event_mgr/: event_mgr.c memory_mgr.c
  group ez_flash
    ../components/easyflash/port/: ef_port.c
    ../components/easyflash/src/: easyflash.c ef_env.c ef_utils.c
  group letter_shell
    ../components/letter_shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDOUT 1.2.0
